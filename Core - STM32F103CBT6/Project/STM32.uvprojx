# Keil uVision project STM32.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Project;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\CMSIS\CM3\DeviceSupport\startup;..\Libraries\STM32F10x_StdPeriph_Driver;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Device;..\API
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/startup/: startup_stm32f10x_md.s
  group Lib
    ../Libraries/STM32F10x_StdPeriph_Driver/: stm32f10x_conf.h
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group Device
    ../Device/: Device_Conf.h
  group Main
    ./: main.c
  group API
    ../API/: API_Conf.h PWM.c RGB.c SYSCLK.c
