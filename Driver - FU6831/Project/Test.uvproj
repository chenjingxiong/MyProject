# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: FU68XX Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\API;..\Driver;..\FU68xxLib\Other;..\FU68xxLib\Outside
  group Main
    ../User/: Init.c Interrupt.c main.c
  group Driver
    ../Driver/: AS5048.c
  group Outside
    ../FU68xxLib/Outside/: FU68xx_CTimer.c FU68xx_SPI.c FU68xx_UART.c FU68xx_ADC.c FU68xx_FOC.c
  group API
    ../API/: API_RGB.c API_ANO_TC.c API_Delay.c
